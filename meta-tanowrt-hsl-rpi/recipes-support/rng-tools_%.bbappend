PR_append = ".rpi0"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"
