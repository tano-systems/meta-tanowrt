#
# SPDX-License-Identifier: MIT
# Copyright (c) 2022 Tano Systems LLC. All rights reserved.
#
PR:append = ".rk0"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/files:"
