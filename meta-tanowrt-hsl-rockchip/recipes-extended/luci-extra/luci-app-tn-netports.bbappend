#
# SPDX-License-Identifier: MIT
# Copyright (c) 2022 Tano Systems LLC. All rights reserved.
#
PR_append_boardcon-em3566 = ".rk0"
PR_append_boardcon-em3568 = ".rk0"
PR_append_rock-pi-s = ".rk0"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"
