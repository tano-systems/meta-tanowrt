# SPDX-License-Identifier: MIT
# Copyright (C) 2021 Anton Kikin <a.kikin@tano-systems.com>

COMPATIBLE_MACHINE_append = "|ls1028ardb-emmc"
