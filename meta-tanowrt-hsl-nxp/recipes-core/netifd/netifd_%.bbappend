#
# SPDX-License-Identifier: MIT
# Copyright (c) 2020-2021 Tano Systems LLC. All rights reserved.
#
PR_append_ls1028ardb = ".nxp3"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"
