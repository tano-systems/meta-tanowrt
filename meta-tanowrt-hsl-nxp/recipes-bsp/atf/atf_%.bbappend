PR_append = ".nxp0"
PLATFORM_nxp-ls1028ardb = "ls1028ardb"
