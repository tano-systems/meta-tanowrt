PR_append = ".nxp0"
COMPATIBLE_MACHINE = "(imxgpu3d)"
