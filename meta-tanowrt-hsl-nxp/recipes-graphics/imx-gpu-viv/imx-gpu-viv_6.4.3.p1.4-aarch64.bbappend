#
# SPDX-License-Identifier: MIT
# Copyright (c) 2020 Tano Systems LLC. All rights reserved.
#
PR_append = ".nxp0"
COMPATIBLE_MACHINE = "(imxgpu3d)"
