COMPATIBLE_MACHINE_append = "|am574x-idk"

PRU_VERSION_am574x-idk = "REV2"
FW_PREFIX_am574x-idk = "am57xx"
