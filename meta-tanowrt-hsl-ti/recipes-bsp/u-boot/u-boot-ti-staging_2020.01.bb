require recipes-bsp/u-boot/u-boot-ti.inc

PR = "r36"

BRANCH = "ti-u-boot-2020.01"

SRCREV = "2781231a33c3d779e32445f4fe55164c45d6d7c1"
