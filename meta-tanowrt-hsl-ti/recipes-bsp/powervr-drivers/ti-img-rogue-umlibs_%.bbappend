#
# SPDX-License-Identifier: MIT
# Copyright (c) 2020 Tano Systems LLC. All rights reserved.
#
TI_IMG_ROGUE_UMLIBS_BRANCH ?= "linuxws/zeus/k5.4/${PV}"
TI_IMG_ROGUE_UMLIBS_SRCREV ?= "6b4d8e538566bbaf6b9c4a24dbecd740d58c1871"
BRANCH = "${TI_IMG_ROGUE_UMLIBS_BRANCH}"
SRCREV = "${TI_IMG_ROGUE_UMLIBS_SRCREV}"
