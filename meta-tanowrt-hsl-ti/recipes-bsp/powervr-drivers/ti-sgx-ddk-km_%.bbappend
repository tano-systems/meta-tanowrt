#
# SPDX-License-Identifier: MIT
# Copyright (c) 2020 Tano Systems LLC. All rights reserved.
#
TI_SGX_DDK_KM_BRANCH ?= "ti-img-sgx/${PV}/k5.4"
TI_SGX_DDK_KM_SRCREV ?= "50c1ec2308b9f64488d252ac55d65b51a0dfe287"
BRANCH = "${TI_SGX_DDK_KM_BRANCH}"
SRCREV = "${TI_SGX_DDK_KM_SRCREV}"
