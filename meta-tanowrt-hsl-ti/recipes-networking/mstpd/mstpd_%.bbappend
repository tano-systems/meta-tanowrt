#
# SPDX-License-Identifier: MIT
# Copyright (c) 2020 Tano Systems LLC. All rights reserved.
#
PR_append_am335x-icev2 = ".ti1"
PR_append_am574x-idk = ".ti0"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"
