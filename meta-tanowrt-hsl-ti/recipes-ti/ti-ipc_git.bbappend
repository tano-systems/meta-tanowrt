PR_append_am574x-idk = ".tano"
ALT_PLATFORM_am574x-idk = "AM572X AM571X"
