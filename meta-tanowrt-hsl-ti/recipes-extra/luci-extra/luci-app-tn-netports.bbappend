# Copyright (C) 2020 Anton Kikin <a.kikin@tano-systems.com>

PR_append_am335x-icev2 = ".ti0"
PR_append_am335x-bbb = ".ti0"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"
