# SPDX-License-Identifier: MIT
# Copyright (C) 2021 Anton Kikin <a.kikin@tano-systems.com>

COMPATIBLE_MACHINE_append = "|am335x-bbb-emmc|am574x-idk-emmc"
