PR_append = ".tano0"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-fix-build-for-old-C99-compilers.patch"
