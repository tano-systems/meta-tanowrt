# Copyright (C) 2019 Anton Kikin <a.kikin@tano-systems.com>
# Released under the MIT license (see COPYING.MIT for the terms)
require recipes-image/images/openwrt-image-full.bb
