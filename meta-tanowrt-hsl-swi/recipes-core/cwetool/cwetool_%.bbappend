#
# SPDX-License-Identifier: MIT
# Copyright (c) 2021 Tano Systems LLC. All rights reserved.
#

# Remove trailing slash (/) from original recipe
S = "${WORKDIR}"
