PR:append = ".swi0"

# Look for files in the layer first
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
