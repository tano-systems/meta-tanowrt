SRC_REPO:remove = "git://salsa.debian.org/debian/bsdiff.git;protocol=https"
SRC_REPO += "git://salsa.debian.org/debian/bsdiff.git;protocol=https;branch=master"
