# This file Copyright (C) 2020 Anton Kikin <a.kikin@tano-systems.com>

PR_append = ".swi0"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"
