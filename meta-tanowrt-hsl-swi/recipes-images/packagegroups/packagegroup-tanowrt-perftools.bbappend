# Copyright (C) 2019 Anton Kikin <a.kikin@tano-systems.com>

PR_append = ".swi0"

# packagegroup-tanowrt-perftools
RDEPENDS_${PN}_remove = "\
	iftop \
"
