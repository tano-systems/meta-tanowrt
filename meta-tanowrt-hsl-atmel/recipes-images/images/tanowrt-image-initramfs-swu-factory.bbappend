# SPDX-License-Identifier: MIT
# Copyright (C) 2021-2022 Anton Kikin <a.kikin@tano-systems.com>

COMPATIBLE_MACHINE_append = "|evb-ksz9477-nand|evb-ksz9563-nand|at91-sama5d2-xplained-emmc|at91-sama5d3-xplained-nand"
