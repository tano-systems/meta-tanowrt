# SPDX-License-Identifier: MIT
# Copyright (C) 2021 Anton Kikin <a.kikin@tano-systems.com>

COMPATIBLE_MACHINE_append = "|evb-ksz9477-nand|evb-ksz9563-nand"
