#
# SPDX-License-Identifier: MIT
# Copyright (c) 2021 Tano Systems LLC. All rights reserved.
#
PR_append_evb-ksz9477 = ".atmel0"
PR_append_evb-ksz9563 = ".atmel0"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"
