#
# SPDX-License-Identifier: MIT
# Copyright (c) 2021-2022 Tano Systems LLC. All rights reserved.
#
PR_append_evb-ksz9477 = ".atmel0"
PR_append_evb-ksz9563 = ".atmel0"
PR_append_at91-sama5d2-xplained = ".atmel0"
PR_append_at91-sama5d3-xplained = ".atmel0"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"
