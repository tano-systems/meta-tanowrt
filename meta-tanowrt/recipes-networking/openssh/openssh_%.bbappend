#
# SPDX-License-Identifier: MIT
# This file Copyright (C) 2020 Anton Kikin <a.kikin@tano-systems.com>
#
PR:append = ".tano0"
RDEPENDS:${PN}-dev = ""
