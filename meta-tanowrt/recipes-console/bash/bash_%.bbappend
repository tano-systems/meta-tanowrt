#
# SPDX-License-Identifier: MIT
# Copyright (c) 2018-2020 Tano Systems LLC. All rights reserved.
#

PR:append = ".tano0"

# Set priority less than busybox
ALTERNATIVE_PRIORITY = "10"
