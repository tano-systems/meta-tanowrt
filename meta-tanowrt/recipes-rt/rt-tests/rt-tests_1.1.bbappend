#
# SPDX-License-Identifier: MIT
# Copyright (c) 2023 Tano Systems LLC. All rights reserved.
#

PR_append = ".tano0"
SRC_URI = "git://git.kernel.org/pub/scm/utils/rt-tests/rt-tests.git;branch=main"
