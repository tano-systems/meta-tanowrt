#
# SPDX-License-Identifier: MIT
#
# Copyright (C) 2018-2020 Anton Kikin <a.kikin@tano-systems.com>
#
inherit kernel-config-depends
