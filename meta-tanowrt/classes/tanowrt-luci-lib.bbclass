#
# LuCI library class
#
# Copyright (c) 2019, Tano Systems. All Rights Reserved.
# Anton Kikin <a.kikin@tano-systems.com>
#
inherit tanowrt-luci-pkg
