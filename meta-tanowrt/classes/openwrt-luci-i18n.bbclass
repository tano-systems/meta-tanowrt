# SPDX-License-Identifier: MIT

python __anonymous() {
    bb.warn("Class openwrt-luci-i18n is deprecated, please use tanowrt-luci-i18n instead")
}

inherit tanowrt-luci-i18n
