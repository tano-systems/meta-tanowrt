python __anonymous() {
    bb.warn("Class openwrt-version is deprecated, please use tanowrt-version instead")
}

inherit tanowrt-version
