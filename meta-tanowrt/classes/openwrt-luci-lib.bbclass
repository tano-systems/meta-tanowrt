python __anonymous() {
    bb.warn("Class openwrt-luci-lib is deprecated, please use tanowrt-luci-lib instead")
}

inherit tanowrt-luci-lib
