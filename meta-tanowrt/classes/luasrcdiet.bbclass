# This file Copyright (C) 2018 Anton Kikin <a.kikin@tano-systems.com>
# Deprecated: Use tanowrt-luci.bblcass instead of luasrcdiet
