python __anonymous() {
    bb.warn("Class openwrt-lua is deprecated, please use tanowrt-lua instead")
}

inherit tanowrt-lua
