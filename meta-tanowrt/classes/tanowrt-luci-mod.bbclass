#
# SPDX-License-Identifier: MIT
#
# LuCI module class
#
# Copyright (c) 2019 Tano Systems LLC. All rights reserved.
# Anton Kikin <a.kikin@tano-systems.com>
#
inherit tanowrt-luci-pkg
