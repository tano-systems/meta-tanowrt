python __anonymous() {
    bb.warn("Class openwrt-kmods is deprecated, please use tanowrt-kmods instead")
}

inherit tanowrt-kmods
