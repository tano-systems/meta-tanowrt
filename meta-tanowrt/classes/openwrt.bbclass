python __anonymous() {
    bb.warn("Class openwrt is deprecated, please use tanowrt instead")
}

inherit openwrt
