python __anonymous() {
    bb.warn("Class openwrt-luci-app is deprecated, please use tanowrt-luci-app instead")
}

inherit tanowrt-luci-app
