#
# SPDX-License-Identifier: MIT
#

TANOWRT_PATH_PREINIT ?= "${nonarch_base_libdir}/preinit"
