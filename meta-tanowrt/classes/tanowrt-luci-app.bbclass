#
# SPDX-License-Identifier: MIT
#
# LuCI application class
#
# Copyright (c) 2018 Tano Systems LLC. All rights reserved.
# Anton Kikin <a.kikin@tano-systems.com>
#
inherit tanowrt-luci-pkg
