python __anonymous() {
    bb.warn("Class openwrt-luci-mod is deprecated, please use tanowrt-luci-mod instead")
}

inherit tanowrt-luci-mod
