python __anonymous() {
    bb.warn("Class openwrt-services is deprecated, please use tanowrt-services instead")
}

inherit tanowrt-services
