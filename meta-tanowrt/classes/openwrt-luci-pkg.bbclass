python __anonymous() {
    bb.warn("Class openwrt-luci-pkg is deprecated, please use tanowrt-luci-pkg instead")
}

inherit tanowrt-luci-pkg
