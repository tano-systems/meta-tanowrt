# SPDX-License-Identifier: MIT

python __anonymous() {
    bb.warn("Class openwrt-luci-proto is deprecated, please use tanowrt-luci-proto instead")
}

inherit tanowrt-luci-proto
