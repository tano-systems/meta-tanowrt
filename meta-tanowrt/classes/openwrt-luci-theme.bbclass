# SPDX-License-Identifier: MIT

python __anonymous() {
    bb.warn("Class openwrt-luci-theme is deprecated, please use tanowrt-luci-theme instead")
}

inherit tanowrt-luci-theme
