#
# SPDX-License-Identifier: MIT
# Copyright (C) 2021 Anton Kikin <a.kikin@tano-systems.com>
#

PACKAGE_ARCH = "${MACHINE_ARCH}"
