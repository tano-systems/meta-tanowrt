require recipes-core/glibc/glibc-scripts.inc
