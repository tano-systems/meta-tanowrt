PR_append = ".tano0"

# Install base-files first
RDEPENDS_${PN} += "base-files"
