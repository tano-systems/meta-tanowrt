PR_append = ".tano0"
KERNEL_MODULE_AUTOLOAD += "cryptodev"
