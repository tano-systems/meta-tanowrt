PR_append = ".tano0"
RDEPENDS_${PN}_remove = "python3"
