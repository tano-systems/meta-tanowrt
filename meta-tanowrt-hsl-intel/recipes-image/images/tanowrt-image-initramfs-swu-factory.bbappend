#
# SPDX-License-Identifier: MIT
# Copyright (c) 2022 Tano Systems LLC. All rights reserved.
#

COMPATIBLE_MACHINE:append = "|intel-x86-common"
