#
# SPDX-License-Identifier: MIT
# Copyright (c) 2022 Tano Systems LLC. All rights reserved.
#
PR_append = ".intel0"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/:"
