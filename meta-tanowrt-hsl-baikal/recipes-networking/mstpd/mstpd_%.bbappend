#
# SPDX-License-Identifier: MIT
# Copyright (c) 2021 Tano Systems LLC. All rights reserved.
#
PR:append:mbm10 = ".baikal0"
PR:append:mbm20 = ".baikal0"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/files:"
