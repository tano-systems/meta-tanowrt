require luasrcdiet_git.bb
inherit native
