PR_append = ".tano0"
INSANE_SKIP_${PN} = "ldflags"
